Properties of the parts of a building model (IFC2X3)

# File
Description: Einstellknopf für Geräte der Serie B2000, Skala 1…6, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA990002, Einstellknopf für Geräte der Serie B2000, Skala 1…6, reinweiß, glänzend
In: Raum
Description: Einstellknopf für Geräte der Serie B2000, Skala 1…6, reinweiß (ähnlich RAL9010), glänzend; Classification: EC000011 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA990002; ModelLabel: ET-10; GlobalTradeItemNumber: 4050528078957; ProductURL: https://alre.de/produkt_MA990002
Pset_Specification - NominalLength: 0.0389 m; NominalWidth: 0.0389 m; NominalDepth: 0.0061 m; NetWeight: 0.004
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 38.9; Ausführung: Drehknopf; Halogenfrei: yes; Höhe: 38.9; Tiefe: 6.12; Verwendung: Thermostat; Oberflächenschutz: unbehandelt; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Aufdruck/Kennzeichnung: sonstige; RAL-Nummer (ähnlich): 9010; Ausführung der Oberfläche: glänzend; Geeignet für Schutzart (IP): sonstige; ETIM-Klasse: EC000011; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA990002.pdf
